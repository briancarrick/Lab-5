# Keil uVision project FinalProject.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: TM4C1230H6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: SimpleProject
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PM
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: startup.s main.c LCD.c SSI.c JLib.c GPIO.c SystemClock.c UART.c TouchScreen.c GPTM.c NVIC.c SSISerialComms.c SYSTIC.c
